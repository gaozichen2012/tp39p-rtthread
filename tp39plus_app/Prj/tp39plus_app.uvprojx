# Keil uVision project tp39plus_app.uvprojx, settings and files
target tp39p (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: tp39plus_app +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/@L.bin ./Objects/@L.axf
  AfterMake: find   "Total R"    ./Listings/@L.map
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEF_DEBUG=2,DEF_IWDG=1,DEF_STYLE=2,
  c include: ..\lib\st_lib\inc;..\bsp\usr;..\bsp;..\bsp\RTT;..\bsp\74hc595;..\bsp\key;..\bsp\keyboard;..\bsp\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x3c000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c4 size 0x7f40
  group usr
    ../bsp/usr/: main.c stm32f0xx_it.c
  group bsp
    ../bsp/: battery.c date_and_time.c gps.c knob.c main_process.c new_ui_data.c pa_led_volume.c poc.c telephone.c timed.c tom_data_conversion.c tom_flash.c tom_interface.c typewriting.c ui.c state.c state_desktop.c state_init.c
  group 74hc595
    ../bsp/74hc595/: hc595.c
  group key
    ../bsp/key/: key.c
  group keyboard
    ../bsp/keyboard/: keyboard.c
  group lcd
    ../bsp/lcd/: font.c lcd_api.c lcd_app.c lcd_drv.c
  group RTT
    ../bsp/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group lib
    ../lib/st_lib/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c system_stm32f0xx.c startup_stm32f030xc.s
software components: RTOS:kernel 3.1.3
