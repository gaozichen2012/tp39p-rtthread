# Keil uVision project VVK-S5.uvprojx, settings and files
target POC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030CC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: TP39PLUS_BOOT +hex
  AfterMake: C:\Keil_v5_525\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/@L.bin ./Objects/@L.axf
  AfterMake: find   "Total R"    ./Listings/@L.map
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,DEF_DEBUG=0,
  c include: ..\Lib\inc;..\Src\app;..\Src\drv;..\Src\usr;..\Src\utils;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Usr
    ../Src/usr/: main.c stm32f0xx_it.c
  group Drv
    ../Src/drv/: uart.c flash.c flash.h GT21L16S2Y.C GT21L16S2Y.H nv3021.c nv3021.h poc.c poc.h
    ../Src/app/: my_string.c my_string.h device.c device.h
    ../Src/: drv_595.c
  group Lib
    ../Lib/src/: system_stm32f0xx.c stm32f0xx_wwdg.c stm32f0xx_usart.c stm32f0xx_tim.c stm32f0xx_syscfg.c stm32f0xx_spi.c stm32f0xx_rtc.c stm32f0xx_rcc.c stm32f0xx_pwr.c stm32f0xx_misc.c stm32f0xx_iwdg.c stm32f0xx_i2c.c stm32f0xx_gpio.c stm32f0xx_flash.c stm32f0xx_exti.c stm32f0xx_dma.c stm32f0xx_dbgmcu.c stm32f0xx_adc.c startup_stm32f030xc.s
